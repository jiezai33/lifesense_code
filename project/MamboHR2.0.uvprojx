# Keil uVision project MamboHR2.0.uvprojx, settings and files
target nrf52832_xxaa_s132 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: MamboHR2.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET S132 NRF_LOG_USES_RTT=1 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  c include: ..\source\config;..\components\ble\ble_advertising;..\components\ble\ble_db_discovery;..\components\ble\common;..\components\ble\device_manager;..\components\drivers_nrf\common;..\components\drivers_nrf\config;..\components\drivers_nrf\delay;..\components\drivers_nrf\gpiote;..\components\drivers_nrf\hal;..\components\drivers_nrf\pstorage;..\components\drivers_nrf\uart;..\components\libraries\button;..\components\libraries\experimental_section_vars;..\components\libraries\fifo;..\components\libraries\fstorage;..\components\libraries\fstorage\config;..\components\libraries\scheduler;..\components\libraries\timer;..\components\libraries\trace;..\components\libraries\uart;..\components\libraries\util;..\components\softdevice\common\softdevice_handler;..\components\softdevice\s132\headers;..\components\softdevice\s132\headers\nrf52;..\components\toolchain;..\source\bsp;..\external\segger_rtt;..\source;..\source\ble_dis;..\source\User;..\source\ble_ancs_android;..\source\ble_ancs_ios;..\source\ble_ota;..\source\ble_trans;..\source\ble_wechat;..\source\common
  asm define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET S132 NRF_LOG_USES_UART=1 NRF52 SOFTDEVICE_PRESENT SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x64000
  memory RVCT9: RAM 0x20002080 size 0xdf80
  group Application
    ../source/: main.c usr_design.c usr_login.c channel_select.c usr_reminder.c usr_device.c md5.c usr_data.c usr_init.c data_transmit.c
    ../source/common/: protoBuf.c
  group Board Support
    ../source/bsp/: bsp.c bsp_btn_ble.c
  group nRF_Services
    ../source/ble_ancs_android/: ble_ancs_android.c
    ../source/ble_ancs_ios/: ble_ancs_ios.c
    ../source/ble_ota/: ble_ota.c
    ../source/ble_trans/: ble_transfer.c
    ../source/ble_wechat/: ble_wechat.c
  group nRF_Comm
    ../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../components/ble/ble_advertising/: ble_advertising.c
    ../components/ble/ble_db_discovery/: ble_db_discovery.c
    ../components/ble/device_manager/: device_manager_peripheral.c
    ../source/ble_dis/: ble_dis.c
  group nRF_Drivers
    ../components/libraries/uart/: app_uart_fifo.c
    ../components/drivers_nrf/delay/: nrf_delay.c
    ../components/drivers_nrf/common/: nrf_drv_common.c
    ../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../components/libraries/button/: app_button.c
    ../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c nrf_log.c
    ../components/libraries/fifo/: app_fifo.c
    ../components/libraries/scheduler/: app_scheduler.c
    ../components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../components/libraries/trace/: app_trace.c
    ../components/libraries/fstorage/: fstorage.c
    ../components/libraries/uart/: retarget.c
  group nRF_SoftDevice
    ../components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group User
    ../source/User/: app_ota.c app_trans.c app_android_ancs.c app_wechat.c
  group Servers_combine
    ../source/ble_ancs_android/: ancs_android_usrdesign.c
    ../source/ble_ota/: ota_usrdesign.c
    ../source/ble_trans/: transfer_usrdesign.c
    ../source/ble_wechat/: wechat_usrdesign.c
  group Common
    ../source/common/: crc_32.c debug.c app_wechat_common.c
  group nRF_Segger_RTT
    ../external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.5.0
